#include <Stepper.h> //引入步進馬達函示庫

const int stepsPerRevolution = 2048;  //此馬達轉一圈為2048步
const int RPM = 5; //馬達旋轉速度
const int btn1=2,btn2=4;

//宣告Stepper物件，的步數和引腳
//引角依序對應驅動版的1N1、1N3、1N2、1N4
Stepper myStepper(stepsPerRevolution, 13, 14, 12, 27);  

void setup() {  
  Serial.begin(115200);
  myStepper.setSpeed(RPM);  //設定馬達轉速
  pinMode(btn1,INPUT);
  pinMode(btn2,INPUT);
}

void loop() {
  //正轉一圈
  if(digitalRead(btn1)==HIGH){
  myStepper.step(20);
  delay(10);
  //倒轉一圈
  }
  else if(digitalRead(btn1)==LOW){
    myStepper.step(5);
    delay(10);
    }
 if(digitalRead(btn2)==LOW){
  myStepper.step(0);
  delay(10);
 }
 else if(digitalRead(btn2)==HIGH){
   myStepper.step(-10);
  delay(10);
  
  }
}
